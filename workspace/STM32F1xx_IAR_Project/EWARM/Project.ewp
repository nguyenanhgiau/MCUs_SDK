# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Inc; ..\StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\StdPeriph_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\StdPeriph_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\..\..\Include; ..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Project
    ./: main.c stm32f10x_it.c
  group StdPeriph_Lib/CMSIS
    ./: system_stm32f10x.c
  group StdPeriph_Lib/EWARM
    ../StdPeriph_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group StdPeriph_Lib/STM32F10x_StdPeriph_Driver
    ../StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
