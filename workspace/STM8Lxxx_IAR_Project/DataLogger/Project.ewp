# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\STM8L15x_StdPeriph_Driver\inc; ..\..\..\chip; ..\..\..\chip\portable; ..\..\..\components\common; ..\..\..\components\dbg; ..\..\..\external\button; ..\..\..\external\led; ..\..\..\drivers\serial; ..\..\..\external\fatfs\inc; ..\..\..\drivers\spi; ..\..\..\drivers\watchdog
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group chip
    ../../../chip/: chip_selection.h
  group chip/port_mcu
    ../../../chip/portable/: port_stm8l.c
  group components/common
    ../../../components/common/: Queue.c Timer.c
  group components/dbg
    ../../../components/dbg/: dbg.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group drivers/spi
    ../../../drivers/spi/: spi.c
  group drivers/watchdog
    ../../../drivers/watchdog/: watchdog.c
  group external/button
    ../../../external/button/: button.c
  group external/fatfs
    ../../../external/fatfs/src/: ff.c ffsystem.c ffunicode.c port_fatfs.c
  group external/led
    ../../../external/led/: led.c
  group Project
    ./: app_main.c main.c prj_options.h stm8l15x_it.c
  group STM8L15x_StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
