# IAR project Backup of Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\STM8S_StdPeriph_Driver\inc; ..\..\..\Include; ..\..\..\Utilities
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group Peripheral
    ../Peripheral/: tim.c usart.c
  group Project
    ./: main.c stm8s_it.c
  group Utilities
    ../../../Utilities/: console.c ringbuf.c
