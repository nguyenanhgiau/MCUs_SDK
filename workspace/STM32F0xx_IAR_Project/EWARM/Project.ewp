# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\Include; ..\..\..\Utilities; ..\..\..\Application\BME280_driver-master; ..\..\..\Application\VL53L0X_API; ..\Driver\STM32F0xx_StdPeriph_Driver\inc; ..\Driver\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar; ..\Driver\CMSIS\Include; ..\Driver\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Application\LED7_SEGMENTS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver/CMSIS
    ./: system_stm32f0xx.c
  group Driver/EWARM
    ../Driver/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
  group Driver/STM32F0xx_StdPeriph_Driver
    ../Driver/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Project
    ./: main.c stm32f0xx_it.c
